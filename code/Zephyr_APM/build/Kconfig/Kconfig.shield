## code/Zephyr_APM/build/Kconfig/Kconfig.shield
```kconfig
osource "C:/ncs/v2.0.0/nrf/boards/shields/*/Kconfig.shield"
osource "C:/ncs/v2.0.0/nfed/boards/shields/*/Kconfig.shield"
```
